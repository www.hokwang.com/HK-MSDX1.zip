Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: HK-MSDX1.IFC
Time: 2022-01-04T06:46:39
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 201607 多功能皂閥-上組件
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 201607多功能皂閥-上桶身
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 950SA導光柱
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: A0127-0018_MSD下蓋
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: A0127-0025_MSD上蓋
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: ASI_鏡櫃_閥體連接頭下
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: C0327-0040_HK-MSD_外殼
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: C529-1鎖頭_Default_1
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: M3×6 TP1螺絲
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: RSD背板
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 圓桶型透視窗_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 給皂機半牙螺絲
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 給皂機半牙螺絲B (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0
